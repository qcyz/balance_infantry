# Keil uVision project CHASSIS.uvprojx, settings and files
target CHASSIS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: CHASSIS +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../ACE-ECF/Bsp/Inc;../Drivers/CMSIS/DSP/Include;../ACE-ECF/Algorithm/inc;../TASK;../COMMUNICATION;../SYSTEM;../IMU;../Behaviour;../Drivers/CMSIS/Lib/ARM
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Core/Src/: stm32f4xx_hal_timebase_tim.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Algorithm
    ../ACE-ECF/Algorithm/src/: fifo.c filter.c lqr.c maths.c pid.c user_lib.c
  group Bsp
    ../ACE-ECF/Bsp/Src/: bsp_dr16.c bsp_Motor_Encoder.c bsp_dwt.c bsp_pwm.c CRC.c bsp_referee.c rm_cilent_ui.c
  group TASK
    ../TASK/: Init_Task.c chassis_task.c Task_Safe.c ins_task.c Ui_task.c
  group SYSTEM
    ../SYSTEM/: chassis_config.h chassis_struct_variables.h
  group Communication
    ../COMMUNICATION/: can1_receive.c can1_send.c can2_receive.c can2_send.c LK9025_communication.c
  group IMU
    ../IMU/: BMI088driver.c BMI088Middleware.c controller.c kalman_filter.c QuaternionEKF.c transfer_function.c
  group Lib
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Behaviour
    ../Behaviour/: chassis_behaviour.c
software components: CMSIS:CORE 4.3.0
